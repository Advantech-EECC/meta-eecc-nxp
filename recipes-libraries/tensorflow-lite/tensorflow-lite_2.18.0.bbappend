FILESEXTRAPATHS:prepend := "${THISDIR}:"

include tensorflow-lite-2.18.0.inc
