FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:rom5720-db5901 = " file://0001-add-imx8mq-rom5720a1-2G-support.patch "
