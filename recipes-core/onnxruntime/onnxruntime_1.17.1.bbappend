do_configure:prepend() {
    sed -i 's/be8be39fdbc6e60e94fa7870b280707069b5b81a/32b145f525a8308d7ab1c09388b2e288312d8eba/g' ${S}/cmake/deps.txt
}
